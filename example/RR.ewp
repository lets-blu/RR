# IAR project RR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\STM32F10x_StdPeriph_Driver\src; USER; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; USER\FreeRTOSV6.1.0; USER\FreeRTOSV6.1.0\include; USER\FreeRTOSV6.1.0\portable\MemMang; USER\FreeRTOSV6.1.0\portable\RVDS\ARM_CM3; Driver; Middleware; Driver\Ethernet; Driver\Ethernet\W5500
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: USER\FreeRTOSV6.1.0
  OBJCOPY.OOCOutputFile: RR.hex
  ILINK.IlinkOutputFile: RR.out
  ILINK.IlinkIcfFile: C:\Users\Blu\Desktop\RR\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    USER/: system_stm32f10x.c
  group Driver
    Driver/: button.c dataselector.c gpiopin.c led.c registergroup.c selectormessage.c shiftregister.c w5500klass.c watchdog.c
  group Ethernet
    Driver/Ethernet/: socket.c spi.c wizchip_conf.c
    Driver/Ethernet/W5500/: w5500.c
  group FreeRTOS
    USER/FreeRTOSV6.1.0/: FreeRTOSConfig.h list.c queue.c tasks.c
    USER/FreeRTOSV6.1.0/portable/MemMang/: heap_2.c
    USER/FreeRTOSV6.1.0/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middleware
    Middleware/: detector.c direction.c ethernet.c ethernetobject.c lamp.c lampstate.c manual.c manualstate.c
  group Startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    USER/: controller.c main.c stm32f10x_conf.h stm32f10x_it.c
